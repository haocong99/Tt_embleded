# Keil uVision project AirCon.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: T6_H01_F50_R00 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030x8,USE_HAL_DRIVER
  c include: .\Drivers\CMSIS\Include;.\Drivers\STM32F0xx_HAL_Driver\Inc;.\Drivers\STM32F0xx_HAL_Driver\Inc\Legacy;.\Inc;.\Drivers\CMSIS\Device\ST\STM32F0xx\Include;.\Drivers\STM32F0xx_HAL_Driver\Inc\Legacy;.\Inc;.\RTE\Device\STM32F030C8
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x10000
  memory RVCT9: RAM 0x200000c0 size 0x2000
  group Source Group 1
    ./Src/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c ringbuf.c rs485.c do.c crc.c bootloader.c S25FL1.c SPI.c Time.c temperature.c system_start.c sharp_air.c REETECH_AIR.c FUNIKI_AIR.c MITSUMISHI_AIR.c GENERAL_AIR.c NAGAKAWA_LC.c NAGAKAWA_LM.c MITSUMISHI_HEAVY_INDUSTRIES.c PANASONIC.c REETECH_YKR.c CARRIER.c GREE.c GALANZ.c NAGAKAWA_R51M.c SAMSUNG.c LG.c TCL.c DAIKIN_AIR.c
  group Driver
    ./Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cec.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_irda.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_msp_template.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_smartcard.c stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_smbus.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_wwdg.c stm32f0xx_ll_adc.c stm32f0xx_ll_comp.c stm32f0xx_ll_crc.c stm32f0xx_ll_crs.c stm32f0xx_ll_dac.c stm32f0xx_ll_dma.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_i2c.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_rtc.c stm32f0xx_ll_spi.c stm32f0xx_ll_tim.c stm32f0xx_ll_usart.c stm32f0xx_ll_utils.c
  group RTE
    ./RTE/Device/STM32F030C8/: system_stm32f0xx.c startup_stm32f030x8.s
software components: CMSIS:CORE 5.0.1
