# Keil uVision project GLCD_75256.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L071RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: GLCD_75256 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\Inc;.\Src;..\GLCD75256;.\Src\glcd;.\u8g2\csrc;.\SPI;..\src;.\src\glcd;..\src_Test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c stm32l0xx_hal_msp.c
    ./Src/: debug.c utils.c rtc.c leds.c watchdog.c buttom.c
  group glcd
    ./: stm32l0xx_it.c
software components: CMSIS:CORE 5.0.1, Device:STM32Cube HAL:ADC 1.8.2, Device:STM32Cube HAL:COMMON 1.8.2, Device:STM32Cube HAL:COMP 1.8.2, Device:STM32Cube HAL:CORTEX 1.8.2, Device:STM32Cube HAL:CRC 1.8.2, Device:STM32Cube HAL:CRYP 1.8.2, Device:STM32Cube HAL:DAC 1.8.2, Device:STM32Cube HAL:DMA 1.8.2, Device:STM32Cube HAL:FIREWALL 1.8.2, Device:STM32Cube HAL:FLASH 1.8.2, Device:STM32Cube HAL:GPIO 1.8.2, Device:STM32Cube HAL:I2C 1.8.2, Device:STM32Cube HAL:I2S 1.8.2, Device:STM32Cube HAL:IRDA 1.8.2, Device:STM32Cube HAL:IWDG 1.8.2, Device:STM32Cube HAL:LCD 1.8.2, Device:STM32Cube HAL:LPTIM 1.8.2, Device:STM32Cube HAL:PCD 1.8.2, Device:STM32Cube HAL:PWR 1.8.2, Device:STM32Cube HAL:RCC 1.8.2, Device:STM32Cube HAL:RNG 1.8.2, Device:STM32Cube HAL:RTC 1.8.2, Device:STM32Cube HAL:SMARTCARD 1.8.2, Device:STM32Cube HAL:SMBUS 1.8.2, Device:STM32Cube HAL:SPI 1.8.2, Device:STM32Cube HAL:TIM 1.8.2, Device:STM32Cube HAL:TSC 1.8.2, Device:STM32Cube HAL:UART 1.8.2, Device:STM32Cube HAL:USART 1.8.2, Device:STM32Cube HAL:WWDG 1.8.2, Device:Startup 1.0.0
